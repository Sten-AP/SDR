options:
  parameters:
    author: sten
    generate_options: qt_gui
    id: Labo_8
    output_language: python
    title: Oefening 4
  states: {}

blocks:
- name: afstand
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '2'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100'
  states: {}
- name: select
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    'true': '1'
    type: int
    value: 'True'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '8'
    type: byte
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: select
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '3'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (65, 66, 67, 10)
  states: {}
- name: channels_channel_model_1
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.0'
    seed: '0'
    taps: '1.0'
  states: {state: bypassed}
- name: digital_psk_demod_0
  id: digital_psk_demod
  parameters:
    constellation_points: '16'
    differential: 'True'
    excess_bw: '0.35'
    freq_bw: 6.28/100.0
    mod_code: '"gray"'
    phase_bw: 6.28/100.0
    samples_per_symbol: '8'
    timing_bw: 6.28/100.0
  states: {}
- name: digital_psk_mod_0
  id: digital_psk_mod
  parameters:
    constellation_points: '16'
    differential: 'True'
    excess_bw: '0.35'
    mod_code: '"gray"'
    samples_per_symbol: '8'
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '12444'
    type: float
  states: {}
- name: network_tcp_source_0
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    port: '12345'
    server: 'False'
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: demoded_signal
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: demoded_signal
  states: {}

connections:
- [blocks_delay_0, '0', virtual_sink_0, '0']
- [blocks_selector_0, '0', digital_psk_mod_0, '0']
- [blocks_uchar_to_float_0, '0', network_tcp_sink_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_vector_source_x_0, '0', blocks_selector_0, '0']
- [channels_channel_model_1, '0', digital_psk_demod_0, '0']
- [channels_channel_model_1, '0', qtgui_const_sink_x_0, '0']
- [digital_psk_demod_0, '0', blocks_delay_0, '0']
- [digital_psk_mod_0, '0', channels_channel_model_1, '0']
- [network_tcp_source_0, '0', blocks_selector_0, '1']
- [virtual_source_0, '0', blocks_unpacked_to_packed_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
