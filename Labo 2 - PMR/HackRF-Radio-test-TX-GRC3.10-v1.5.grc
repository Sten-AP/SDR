options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: AFgain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '50'
    value: '10'
  states: {}
- name: PMR
  id: variable_qtgui_chooser
  parameters:
    labels: '[]'
    num_opts: '0'
    options: '[435000000, 446006250,446018750,446031250 ,446043750,446056250,446068750,446081250,446093750]'
    type: int
    value: '446006250'
  states: {}
- name: decpol
  id: variable
  parameters:
    value: '6'
  states: {}
- name: intpol
  id: variable
  parameters:
    value: '125'
  states: {}
- name: ptt
  id: variable_qtgui_push_button
  parameters:
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: analog_fm_preemph_0
  id: analog_fm_preemph
  parameters:
    fh: '-1.0'
    samp_rate: samp_rate
    tau: '50e-6'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: '0.5'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: pmrtest
    repeat: 'True'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: AFgain
    type: float
  states: {}
- name: note_0
  id: note
  parameters:
    note: PMR+((1-ptt)*(-13500000))
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    freq0: PMR+((1-ptt)*(-13500000))
    gain0: '10'
    if_gain0: '30'
    sample_rate: samp_rate*intpol/decpol
    sync: sync
    type: fc32
  states: {}
- name: pttsw
  id: blocks_multiply_const_vxx
  parameters:
    const: ptt
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decpol
    interp: intpol
    type: ccc
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    amp: 'True'
    center_freq: PMR+((1-ptt)*(-13500000))
    samp_rate: samp_rate*intpol/decpol
    type: fc32
  states: {state: disabled}

connections:
- [analog_fm_preemph_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_frequency_modulator_fc_0, '0', pttsw, '0']
- [audio_source_0, '0', analog_fm_preemph_0, '0']
- [blocks_file_source_0, '0', analog_fm_preemph_0, '0']
- [blocks_multiply_const_vxx_0, '0', analog_frequency_modulator_fc_0, '0']
- [pttsw, '0', qtgui_freq_sink_x_0, '0']
- [pttsw, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', osmosdr_sink_0, '0']
- [rational_resampler_xxx_0, '0', soapy_hackrf_sink_0, '0']

metadata:
  file_format: 1
