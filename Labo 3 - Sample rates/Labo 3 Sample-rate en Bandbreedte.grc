options:
  parameters:
    generate_options: qt_gui
    id: Labo_3
    output_language: python
    title: Sample-rate en Bandbreedte
  states: {}

blocks:
- name: frequentie
  id: variable_qtgui_range
  parameters:
    start: 88e6
    step: 100e3
    stop: 108e6
    value: 100e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: frequentie
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
